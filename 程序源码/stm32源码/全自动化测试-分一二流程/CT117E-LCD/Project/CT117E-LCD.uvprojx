# Keil uVision project CT117E-LCD.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CT117E-LCD +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,_1010MODE
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Library
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c misc.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_dac.c stm32f10x_tim.c
    ../Sre/: stm32f10x_it.c stm32f10x_adc.c
  group Driver
    ../Sre/: key.c SK9822.c led.c MicArray.c delay.c lcd.c usart.c malloc.c 74LV4052.c sydw.c servo.c jd.c timer.c sys.c usart3.c esp8266.c beep.c adc.c pid.c GPIO.c uart2.c dac.c uart4.c
    ../Inc/: Draw.c
  group User
    ../Sre/: main.c
  group dsp
    ../Sre/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
